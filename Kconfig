## Kconfig
```kconfig
menu "HTTPD FOTA settings"

    config APP_UPDATE_CHECK_PROJECT_NAME
        bool "Check PROJECT_NAME to be same as on running firmware image"
        default n

endmenu
```
